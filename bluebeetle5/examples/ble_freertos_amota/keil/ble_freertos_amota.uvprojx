# Keil uVision project ble_freertos_amota.uvprojx, settings and files
target ble_freertos_amota (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_freertos_amota
  AfterMake: fromelf --bin --output bin\ble_freertos_amota.bin bin\ble_freertos_amota.axf
  AfterMake: fromelf -cedrst --output bin\ble_freertos_amota.txt bin\ble_freertos_amota.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: WSF_TRACE_ENABLED AM_MULTIBOOT_CONFIG_FILE=\"amota_profile_config.h\" AM_PART_APOLLO3 AM_FREERTOS AM_CUSTOM_BDADDR AM_PACKAGE_BGA AM_DEBUG_PRINTF keil
  c include: ../../../../../bootloader;../../../../../mcu/apollo3;../../../../../third_party/exactle/sw/hci/ambiq/apollo3;../../../../../third_party/exactle/ws-core/sw/wsf/ambiq;../../../../../third_party/exactle/sw/stack/cfg;../../../../../devices;../../../../../third_party/exactle/sw/profiles/uribeacon;../../../../../third_party/exactle/sw/sec/common;../../../../../third_party/exactle/ws-core/include;../../../../../third_party/exactle/sw/hci/ambiq;../../../../../third_party/FreeRTOS9/Source/include;../../../../../third_party/exactle/apollo-host/projects/common;../../../../../CMSIS/ARM/Include;../../../../../third_party/exactle/ws-core/sw/wsf/include;../../../../../CMSIS/AmbiqMicro/Include;../../../../../third_party/exactle/sw/hci/include;../../../../../utils;../../../../../third_party/uecc/micro-ecc;../../../../../third_party/exactle/sw/stack/include;../../../../..;../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2;../../../../../third_party/exactle/sw/services;../../../../../third_party/exactle/sw/profiles/rscp;../../../../../third_party/exactle/sw/profiles/hid;../../../bsp;../../../../../ambiq_ble/apps/amota;../../../../../third_party/exactle/sw/apps/app/include;../../../../../third_party/exactle/sw/sec/include;../../../../../third_party/exactle/sw/profiles/hrps;../../../../../ambiq_ble/profiles/amota;../../../../../third_party/exactle/ws-core/sw/util;../../../../../third_party/exactle/sw/apps/app;../src;../../../../../ambiq_ble/services;../../../../../third_party/exactle/sw/profiles/bas;../../../../../third_party/exactle/sw/stack/hci
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\ble_freertos_amota.sct
  link misc: ../../../../../mcu/apollo3/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group FreeRTOS9_AMapollo2
    ../../../../../third_party/FreeRTOS9/Source/portable/Keil/AMapollo2/: port.c
  group exactle_apollo3
    ../../../../../third_party/exactle/sw/hci/ambiq/apollo3/: hci_drv_apollo3.c
  group exactle_generic
    ../../../../../third_party/exactle/sw/apps/app/generic/: app_db.c app_hw.c app_ui.c
  group exactle_ambiq
    ../../../../../third_party/exactle/ws-core/sw/wsf/ambiq/: wsf_assert.c wsf_math.c wsf_os.c wsf_trace.c
  group exactle_cfg
    ../../../../../third_party/exactle/sw/stack/cfg/: cfg_stack.c
  group exactle_common
    ../../../../../third_party/exactle/sw/sec/common/: sec_aes.c sec_cmac.c sec_ecc_hci.c sec_main.c
  group exactle_rscp
    ../../../../../third_party/exactle/sw/profiles/rscp/: rscps_main.c
  group exactle_hid
    ../../../../../third_party/exactle/sw/profiles/hid/: hid_main.c
  group amota
    ../../../../../ambiq_ble/apps/amota/: amota_main.c
  group exactle_ambiq
    ../../../../../third_party/exactle/sw/hci/ambiq/: hci_cmd.c hci_core.c hci_core_ps.c hci_evt.c hci_tr.c hci_vs.c
  group exactle_hrps
    ../../../../../third_party/exactle/sw/profiles/hrps/: hrps_main.c
  group amota
    ../../../../../ambiq_ble/profiles/amota/: amotas_main.c
  group exactle_common
    ../../../../../third_party/exactle/ws-core/sw/wsf/common/: wsf_buf.c wsf_efs.c wsf_msg.c wsf_queue.c wsf_timer.c
  group exactle_util
    ../../../../../third_party/exactle/ws-core/sw/util/: bda.c bstream.c calc128.c crc32.c print.c terminal.c wstr.c
  group src
    ../src/: ble_freertos_amota.c radio_task.c rtos.c
  group services
    ../../../../../ambiq_ble/services/: svc_amdtp.c svc_amotas.c
  group exactle_hidapp
    ../../../../../third_party/exactle/sw/apps/hidapp/: hidapp_main.c
  group exactle_bas
    ../../../../../third_party/exactle/sw/profiles/bas/: bas_main.c
  group exactle_hci
    ../../../../../third_party/exactle/sw/stack/hci/: hci_main.c
  group bootloader
    ../../../../../bootloader/: am_bootloader.c am_multi_boot.c
  group exactle_app
    ../../../../../third_party/exactle/sw/apps/app/: app_disc.c app_main.c app_master.c app_master_leg.c app_server.c app_slave.c app_slave_leg.c app_terminal.c
  group exactle_services
    ../../../../../third_party/exactle/sw/services/: svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group FreeRTOS9_MemMang
    ../../../../../third_party/FreeRTOS9/Source/portable/MemMang/: heap_2.c
  group FreeRTOS9_Source
    ../../../../../third_party/FreeRTOS9/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../third_party/uecc/keil/bin/: lib_uecc.lib
    ../../../../../mcu/apollo3/hal/keil/bin/: libam_hal.lib
    ../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../third_party/exactle/projects/generic/stacklib/keil/Cortex-M4/: stacklib.lib
